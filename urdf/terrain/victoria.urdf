Commit message: add hadley mountain map

File: urdf/terrain/victoria.urdf (robot description, URDF)
Before this commit: robot myfirst, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=package://scarab_description/meshes/terrain/victoria.dae
